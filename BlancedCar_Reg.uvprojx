# Keil uVision project BlancedCar_Reg.uvprojx, settings and files
target Target_1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BlancedCar_Reg +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD
  c include: .\App;.\Com;.\Dri;.\Int\OLED;.\Mid\FreeRTOS;.\Start;.\User;.\Mid\FreeRTOS\Include;.\Mid\FreeRTOS\Portable;.\Int
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c
  group Dri
    ./Dri/: Dri_UART1.c Dri_SPI.c Dri_TIM.c Dri_I2C.c Dri_ADC1.c
  group Int
    ./Int/OLED/: Int_OLED.c
    ./Int/: Int_HallEncoder.c Int_TB6612.c Int_MPU6050.c
  group App
    ./App/: App_Task.c App_Car.c
  group Com
    ./Com/: logger.c Com_Delay.c Com_KalmanFilter.c
  group FreeRTOS
    ./Mid/FreeRTOS/: FreeRTOSConfig.h
  group FreeRTOS/Source
    ./Mid/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Portable
    ./Mid/FreeRTOS/Portable/: heap_4.c port.c
